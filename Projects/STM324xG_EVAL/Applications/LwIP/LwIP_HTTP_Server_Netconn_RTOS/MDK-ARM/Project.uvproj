# Keil uVision project Project.uvproj, settings and files
target STM324xG_EVAL (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM324xG_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STM324xG_EVAL,
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM324xG_EVAL;..\..\..\..\..\..\Drivers\BSP\Components;..\..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\;..\..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\ipv4                                                              ;..\..\..\..\..\..\Middlewares\Third_Party\LwIP\system;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\..\..\..\Utilities;..\..\..\..\..\..\Utilities\Log
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: app_ethernet.c ethernetif.c fs.c httpserver-netconn.c main.c stm32f4xx_it.c
  group Application/Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
  group Docs
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components//stmpe811/: stmpe811.c
    ../../../../../../Drivers/BSP/Components/ili9325/: ili9325.c
  group Drivers/BSP/STM324xG_EVAL
    ../../../../../../Drivers/BSP/STM324xG_EVAL/: stm324xg_eval.c stm324xg_eval_io.c stm324xg_eval_lcd.c stm324xg_eval_sram.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_sram.c stm32f4xx_hal_uart.c stm32f4xx_ll_fsmc.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: def.c dhcp.c dns.c init.c lwip_timers.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group Middlewares/LwIP/Core/IPv4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group Middlewares/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: etharp.c
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
