# Keil uVision project Project.uvproj, settings and files
target STM32F429I_DISCO (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F429I_DISCO
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM32F429I_DISCO,
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\Components;..\..\..\..\..\..\Drivers\BSP\STM32F429I-Discovery;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\..\..\..\Utilities;
  asm include: ..\Inc,
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User
    ../Src/: main.c stm32f4xx_it.c
  group Docs
    ../: readme.txt
  group Drivers/BSP/STM32429I_DISCO
    ../../../../../../Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
