# Keil uVision project Project.uvproj, settings and files
target STM32F429I_DISCO_MB1075 (ARM-ADS)
  device: STM32F429NI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F429I_DISCO_MB1075
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F429xx,USE_STM32F429I_DISCO,
  c misc: --C99
  c include: ..\Inc;..\Demo;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32F429I-Discovery;..\..\..\..\..\..\Middlewares\ST\STemWin\inc
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/Demo
    ../Demo/: GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User
    ../Src/: calibration.c main.c rtc.c stm32f4xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ili9341/: ili9341.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Drivers/BSP/STM324x9I_DISCO
    ../../../../../../Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery_io.c stm32f429i_discovery_sdram.c stm32f429i_discovery_ts.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fmc.c
  group Middlewares/STemWin/Config
    ../../../../../../Middlewares/ST/STemWin/OS/: GUI_X.c
    ../Src/: GUIConf.c LCDConf_stm32f429i_disco_MB1075.c
  group Middlewares/STemWin/Lib
    ../../../../../../Middlewares/ST/STemWin/Lib/: STemWin524b_CM4_IAR.a
