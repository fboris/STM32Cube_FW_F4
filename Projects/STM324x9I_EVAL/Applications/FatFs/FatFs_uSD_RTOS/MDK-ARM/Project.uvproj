# Keil uVision project Project.uvproj, settings and files
target STM324x9I_EVAL (ARM-ADS)
  device: STM32F429NI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM324x9I_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM324x9I_EVAL,
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM324x9I_EVAL;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;
  asm include: ..\Inc,
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User
    ../Src/: main.c stm32f4xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stmpe1600/: stmpe1600.c
  group Drivers/BSP/STM324x9I_EVAL
    ../../../../../../Drivers/BSP/STM324x9I_EVAL/: stm324x9i_eval.c stm324x9i_eval_io.c stm324x9i_eval_sd.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_nand.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c stm32f4xx_ll_fmc.c stm32f4xx_ll_sdmmc.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Middlewares/FatFs/Options
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
