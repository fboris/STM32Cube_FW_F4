# IAR project Project.ewp, settings and files
configuration STM324x9I_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429NI ST STM32F429NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx; USE_STM324x9I_EVAL
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\inc; ..\..\..\..\..\..\Drivers\BSP\STM324x9I_EVAL; ..\..\..\..\..\..\Utilities; ..\..\..\..\..\..\Utilities\fonts; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f429xx.s
  group Application/User
    ../Src/: main.c stm32f4xx_it.c ts_calibration.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stmpe1600/: stmpe1600.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../../../Drivers/BSP/Components/ts3510/: ts3510.c
  group Drivers/BSP/STM324x9I_EVAL
    ../../../../../../Drivers/BSP/STM324x9I_EVAL/: stm324x9i_eval.c stm324x9i_eval_io.c stm324x9i_eval_lcd.c stm324x9i_eval_sd.c stm324x9i_eval_sdram.c stm324x9i_eval_ts.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_uart.c stm32f4xx_ll_fmc.c stm32f4xx_ll_sdmmc.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
