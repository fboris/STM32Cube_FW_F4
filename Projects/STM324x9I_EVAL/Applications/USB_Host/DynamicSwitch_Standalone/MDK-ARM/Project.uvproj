# Keil uVision project Project.uvproj, settings and files
target STM324x9I-EVAL_USBH-FS (ARM-ADS)
  device: STM32F429NI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM324x9I-EVAL_USBH-FS
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM324x9I_EVAL,USE_USB_FS,
  c misc: --C99
  c include: ..\inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\AUDIO\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\HID\Inc;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers;..\..\..\..\..\..\Drivers\BSP\STM324x9I_EVAL;..\..\..\..\..\..\Utilities\Log;
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User
    ../Src/: main.c menu.c stm32f4xx_it.c usbh_conf.c usbh_diskio.c
  group Application/User/AUDIO
    ../Src/: audio.c audio_explorer.c audio_menu.c
  group Application/User/HID
    ../Src/: hid_menu.c keyboard.c mouse.c
  group Application/User/MSC
    ../Src/: file_operations.c msc_explorer.c msc_menu.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stmpe1600/: stmpe1600.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Drivers/BSP/STM324x9I_EVAL
    ../../../../../../Drivers/BSP/STM324x9I_EVAL/: stm324x9i_eval.c stm324x9i_eval_io.c stm324x9i_eval_lcd.c stm324x9i_eval_sd.c stm324x9i_eval_sdram.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_uart.c stm32f4xx_ll_fmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Middlewares/STM32_USBH_Library/Class/AUDIO
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/AUDIO/Src/: usbh_audio.c
  group Middlewares/STM32_USBH_Library/Class/HID
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Src/: usbh_hid.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_HOST_Library/Core/Src/: usbh_pipes.c
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c
  group Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
target STM324x9I-EVAL_USBH-HS (ARM-ADS)
  device: STM32F429NI STMicroelectronics
  cpu: as above
  output: STM324x9I-EVAL_USBH-HS
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM324x9I_EVAL,USE_USB_HS,
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
target STM324x9I-EVAL_USBH-HS-IN-FS (ARM-ADS)
  device: STM32F429NI STMicroelectronics
  cpu: as above
  output: STM324x9I-EVAL_USBH-HS-IN-FS
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM324x9I_EVAL,USE_USB_HS,USE_USB_HS_IN_FS,
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
