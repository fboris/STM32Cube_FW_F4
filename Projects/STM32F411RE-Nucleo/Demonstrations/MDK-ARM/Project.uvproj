# Keil uVision project Project.uvproj, settings and files
target STM32F4xx_Nucleo (ARM-ADS)
  device: STM32F411RE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(84000000) ELITTLE
  output: STM32F4xx_Nucleo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE,USE_STM32F4XX_NUCLEO,
  c misc: --C99
  c include: ..\Inc;..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo;..\..\..\..\Drivers\BSP\Adafruit_Shield;..\..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User
    ../Src/: fatfs_storage.c main.c stm32f4xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Adafruit_Shield
    ../../../../Drivers/BSP/Adafruit_Shield/: stm32_adafruit_lcd.c stm32_adafruit_sd.c
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/st7735/: st7735.c
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c
  group Middlewares/FatFs/Core
    ../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
